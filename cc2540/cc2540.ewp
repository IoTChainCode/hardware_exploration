# IAR project cc2540.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: OSAL_CBTIMER_NUM_TASKS=1; HAL_DMA=TRUE; HAL_UART=TRUE; INT_HEAP_LEN=2000; xHALNODEBUG; xHAL_AES_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; xHAL_LCD=TRUE; xHAL_LED=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\zhuo\github\hardware_project\cc2540\hal\include; C:\zhuo\github\hardware_project\cc2540\hal\target\CC2540EB; C:\zhuo\github\hardware_project\cc2540\osal\include; C:\zhuo\github\hardware_project\cc2540\ble\include; C:\zhuo\github\hardware_project\cc2540\ble\controller\CC254x\include; C:\zhuo\github\hardware_project\cc2540\ble\hci; C:\zhuo\github\hardware_project\cc2540\ble\host; C:\zhuo\github\hardware_project\cc2540\profiles; C:\zhuo\github\hardware_project\cc2540\profiles\SimpleProfile; C:\zhuo\github\hardware_project\cc2540\profiles\Roles; C:\zhuo\github\hardware_project\cc2540\profiles\DevInfo; C:\zhuo\github\hardware_project\cc2540\common\cc2540; C:\zhuo\github\hardware_project\cc2540\common\npi
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\common\cc2540\ti_51ew_cc2540b.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group app
    ./: callback.c callback.h cc2540.c cc2540.h include.c include.h
  group common
    common/npi/: npi.c npi.h
    common/cc2540/: OnBoard.c OnBoard.h
  group hal
    hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_aes.h hal_board_cfg.h hal_dma.c hal_dma.h hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_mcu.h hal_startup.c hal_types.h hal_uart.c
    hal/include/: hal_adc.h hal_drivers.h hal_flash.h hal_key.h hal_uart.h
    hal/common/: hal_assert.c hal_drivers.c
  group lib
    lib/: CC2540_BLE.lib CC2540_BLE_cent.lib CC2540_BLE_peri.lib CC254x_BLE_HCI_TL_None.lib
  group osal
    osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    osal/mcu/cc2540/: osal_snv.c
  group profiles
    profiles/Roles/: central.c central.h combine.c combine.h gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    profiles/DevInfo/: devinfoservice.c devinfoservice.h
    profiles/: gapgattserver.h gatt_profile_uuid.h gattservapp.h hci_ext.h
    ble/host/: gatt_uuid.c linkdb.h
    profiles/GATT/: gattservapp_util.c
    profiles/SimpleProfile/: simpleGATTprofile.c simpleGATTprofile.h
