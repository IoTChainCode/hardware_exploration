# Keil uVision project stm32l431.uvprojx, settings and files
target stm32l431 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32l431 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: drivers\STM32L4xx_HAL_Driver\Inc;drivers\STM32L4xx_HAL_Driver\Inc\Legacy;drivers\CMSIS\Device\ST\STM32L4xx\Include;drivers\CMSIS\Include;drivers\Hardware\OLED;drivers\Hardware\AT;drivers\Hardware\BH1750;drivers\Hardware\DHT11;drivers\Hardware\GPS;components\cmsis;components\cmsis\1.0;components\cmsis\2.0;kernel\base\include;kernel\include;kernel\extended\include;arch\arm\arm-m\include;arch\arm\arm-m\cortex-m4;drivers\;kernel\config;.\;.\components\security\mbedtls\mbedtls-2.6.0\include\mbedtls;.\components\security\mbedtls\mbedtls-2.6.0\include;.\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\stm32l431.sct
  group app
    ./: stm32l431.c los_startup_keil.s include.c include.h stm32l431.h ota.c ota.h
  group driver
    ./drivers/: adc.c delay.c gpio.c i2c.c los_dev_st_uart.c stm32l4xx_it.c usart.c sys_init.c system_stm32l4xx.c
    ./drivers/Hardware/GPS/: gps.c
    ./drivers/Hardware/DHT11/: DHT11_BUS.c
    ./drivers/Hardware/OLED/: oled.c
    ./drivers/Hardware/AT/: at.c
    ./drivers/Hardware/BH1750/: BH1750.c
  group liteos
    ./components/cmsis/: cmsis_liteos.c
    ./kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ./kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ./kernel/base/mem/bestfit_little/: los_heap.c los_membox.c los_memcheck.c los_memory.c
    ./kernel/base/mem/common/: los_slab.c los_slabmem.c
    ./kernel/base/misc/: los_misc.c
    ./kernel/base/om/: los_err.c
    ./kernel/: los_init.c
    ./kernel/extended/tickless/: los_tickless.c
    ./arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ./arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group hal
    ./drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rng.c
  group crypto
    ./crypto/: ecc.c ecc.h aes.c aes.h drng.c drng.h crypt_sha256.c crypt_sha256.h crypt_sha3.c crypt_sha3.h KeccakF-1600-reference.c KeccakF-1600-reference.h
